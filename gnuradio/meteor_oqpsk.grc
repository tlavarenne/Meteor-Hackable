options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0
    label0: 72k
    label1: 80k
    num_opts: '2'
    option0: '72000'
    option1: '80000'
    orient: Qt.QHBoxLayout
    type: real
    value: '72000'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label0: 137.1e6
    label1: 137.9e6
    num_opts: '2'
    option0: 137.1e6
    option1: 137.9e6
    orient: Qt.QHBoxLayout
    type: real
    value: 137.9e6
    widget: radio_buttons
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: loop_costas
  id: variable_qtgui_range
  parameters:
    start: '2.5e-3'
    step: '2.5e-3'
    stop: '25e-3'
    value: '10e-3'
  states: {}
- name: multiply_const
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '127'
    value: '58'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.6e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: gain auto
    gain: '1.0'
    max_gain: '4000'
    rate: '1000e-4'
    reference: '0.6'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      Retarder la voie I
           d'un demi-symbole
          pour "rattrapper" 
          OQPSK
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Enregistrement 
      des softs bits
    file: meteorn2_3x_cut2.s
    type: byte
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: raw_meteor24_2.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lavarenne/METEOR 2-3_2025/cut1.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Constante à ajuster pour 
      avoir des valeurs centrées 
      autour de +/- 90
    const: multiply_const
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_1
  id: digital_constellation_soft_decoder_cf
  parameters:
    comment: |-
      digital.constellation_calcdist(
                         ([-1-1j, -1+1j, 1+1j, 1-1j]),
                          ([0, 1, 3, 2]), 4, 1).base()
      décodage selon le code de Gray
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Synchro de phase 
      (suppression de la diff de frequence 
      entre OL et émetteur)
    order: '4'
    w: loop_costas
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Synchronisation de l'instant de décision
      On garde un échantillon par symbole
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '.25'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate*9/100/baud
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: |-
      Affichage de la constellation
      stabilisée
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '256'
    comment: |-
      Affichage de l'histogramme des valeurs
      (pour controle)
    size: '1024'
    type: float
    xmax: '128'
    xmin: '-128'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      1.6Msps * 9/100 = 144 ksps
      --> 2 ech / symbole
    decim: '100'
    interp: '9'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    comment: filtrage des symboles
    decim: '1'
    gain: '1'
    ntaps: '201'
    samp_rate: samp_rate*9/100
    sym_rate: baud
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_float_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_delay_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [digital_constellation_soft_decoder_cf_1, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_soft_decoder_cf_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_2, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
